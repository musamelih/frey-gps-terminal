# Keil uVision project project.uvproj, settings and files
target RT-Thread STM32 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: rtthread-stm32 +hex
  c flags: Optim=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\drivers;..\stm32lib_v3.5\STM32F10x_StdPeriph_Driver\inc;..\stm32lib_v3.5\CMSIS\CM3\CoreSupport;..\stm32lib_v3.5\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\RT-Thread_1.1.1;..\RT-Thread_1.1.1\include;..\RT-Thread_1.1.1\libcpu\arm\cortex-m3;..\RT-Thread_1.1.1\libcpu\arm\common
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Applications
    ../applications/: application.c startup.c
  group Drivers
    ../drivers/: board.c led.c rtc.c serial.c stm32f10x_it.c usart.c
  group Kernel
    ../RT-Thread_1.1.1/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c slab.c thread.c timer.c
  group CORTEX-M3
    ../RT-Thread_1.1.1/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
    ../RT-Thread_1.1.1/libcpu/arm/common/: showmem.c backtrace.c div0.c
  group STM32_StdPeriph
    ../stm32lib_v3.5/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../stm32lib_v3.5/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../stm32lib_v3.5/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../stm32lib_v3.5/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
